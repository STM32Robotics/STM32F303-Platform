# Keil uVision project StarterTemplate.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StarterTemplate
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: SysTick.cpp SysTick.h stm32f30x.h stm32f30x_adc.h stm32f30x_adc.cpp stm32f30x_can.cpp stm32f30x_comp.cpp stm32f30x_crc.cpp stm32f30x_dac.cpp stm32f30x_dbgmcu.cpp stm32f30x_dma.cpp stm32f30x_exti.cpp stm32f30x_flash.cpp stm32f30x_fmc.cpp stm32f30x_gpio.cpp stm32f30x_hrtim.cpp stm32f30x_i2c.cpp stm32f30x_iwdg.cpp stm32f30x_misc.cpp stm32f30x_opamp.cpp stm32f30x_pwr.cpp stm32f30x_rcc.cpp stm32f30x_rtc.cpp stm32f30x_spi.cpp stm32f30x_syscfg.cpp stm32f30x_tim.cpp stm32f30x_usart.cpp stm32f30x_wwdg.cpp stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_fmc.h stm32f30x_gpio.h stm32f30x_hrtim.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h stm32f30x_conf.h stm32f30x_it.h stm32f30x_it.cpp system_stm32f30x.cpp system_stm32f30x.h startup_stm32f303xe.s USARTSystem.h USARTSystem.cpp Utilities.cpp main.h EncoderSystem.cpp EncoderSystem.h DCMotorSystem.cpp DCMotorSystem.h RS232.h Utilities.h RS232.cpp StepperMotor.cpp StepperMotor.h main.cpp CommandSystem.cpp CommandSystem.h StringClass.cpp StringClass.h TimerCallback.cpp TimerCallback.h LCDSystem.cpp LCDSystem.h ServoSystem.cpp ServoSystem.h
software components: CMSIS:CORE 5.1.2
